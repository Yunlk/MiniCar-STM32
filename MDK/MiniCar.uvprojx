# Keil uVision project MiniCar.uvprojx, settings and files
target MiniCar (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=5
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HAL\BEEP;..\HAL\KEY;..\HAL\LED;..\HAL\MOTOR;..\HAL\UART;..\SYS\delay;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c command.h car.h car.c
  group SYS
    ../SYS/delay/: delay.c delay.h
  group HAL
    ../HAL/MOTOR/: motor.c motor.h
    ../HAL/KEY/: key.c key.h
    ../HAL/LED/: led.c led.h
    ../HAL/UART/: uart.c uart.h
    ../HAL/BEEP/: beep.c beep.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
